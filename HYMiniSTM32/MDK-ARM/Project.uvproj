# Keil uVision project Project.uvproj, settings and files
target MediaControlSystem (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MCS +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\TouchPanel;..\USER\GLCD;..\USER\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../USER/: stm32f10x_it.c stm32f10x_conf.h
    ./: main.cpp Display1.cpp Display1.h USARTHandler.cpp USARTHandler.h
  group GLCD
    ../USER/GLCD/: GLCD.c HzLib.c AsciiLib.c
  group SysTick
    ../USER/SysTick/: systick.c stm32f10x_systick.c
  group TouchPanel
    ../USER/TouchPanel/: TouchPanel.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group MyGUI
    ./: MyDisplay.cpp MyDisplay.h MyUtils.h MyText.cpp MyText.h MyBox.cpp MyBox.h MyTriangle.cpp MyTriangle.h
